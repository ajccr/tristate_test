*test tristate buffer xspice co-sim

*uncomment to test xspice netlist generated by current qflow spi2xspice.py
*.include tristate_test.out.spice

*uncomment to test patched xspice netlist
.include tristate_test_patched.out.spice

xitest 0 vddd en in out tristate_test

v0 in 0 pulse (1.8 0 10n 1n 1n 50n 100n)
v1 en 0 pwl (0 1.8 1u 1.8 1.001u 0)
v2 vddd 0 DC=1.8

.control
tran 1n 2u

plot in 'en+2' 'out+4'
.endc
